# IAR project multichannel-audio-module.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: multichannel-audio-module-mcu-prog-v01-220719.hex
  ILINK.IlinkOutputFile: multichannel-audio-module.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/: clk.c clk.h flash.c flash.h gpio.c gpio.h i2c.c i2c.h int.c int.h main.c main.h stm8s.h tim4.c tim4.h uart.c uart.h
